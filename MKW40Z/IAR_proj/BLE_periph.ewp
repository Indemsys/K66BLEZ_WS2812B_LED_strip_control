# IAR project BLE_periph.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKW40Z160xxx4 Freescale MKW40Z160xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; IAR; CPU_MKW40Z160VHT4; FSL_RTOS_FREE_RTOS; USB_KW40Z; DONGLE
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.PreInclude: D:\Embedded\Projects\Barduva\SB200M2\BackEndUnit_v3.0\Firmware_Bluetooth\App\app_preinclude.h
  ICCARM.CCIncludePath2: ..\App; ..\BLE_App\Battery_Service; ..\BLE_App\DeviceInfo_Service; ..\BLE_App\HeartRate_Service; ..\BLE_App\HID_Service; ..\BLE_App\ImmediateAlert_Service; ..\BLE_App\LinkLoss_Service; ..\BLE_App\TxPower_Service; ..\BLE_App; ..\BLE_GATT_DB\macros; ..\BLE_GATT_DB; ..\BluetoothLE; ..\Board; ..\CMSIS; ..\Framework\Flash; ..\Framework; ..\FreeRTOS\config; ..\FreeRTOS\include; ..\FreeRTOS\port; ..\HAL; ..\OSA; ..\Peripherial; ..\RTT; ..\BLE_App\K66BLEZ_services
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  AARM.AUserIncludes: ..\App; ..\BLE_App\Battery_Service; ..\BLE_App\DeviceInfo_Service; ..\BLE_App\HeartRate_Service; ..\BLE_App\HID_Service; ..\BLE_App\ImmediateAlert_Service; ..\BLE_App\LinkLoss_Service; ..\BLE_App\TxPower_Service; ..\BLE_App; ..\BLE_GATT_DB\macros; ..\BLE_GATT_DB; ..\BluetoothLE; ..\Board; ..\CMSIS; ..\Framework\Flash; ..\Framework; ..\FreeRTOS\config; ..\FreeRTOS\include; ..\FreeRTOS\port; ..\HAL; ..\OSA; ..\Peripherial; ..\RTT
  OBJCOPY.OOCOutputFile: BLE_periph.hex
  ILINK.IlinkOutputFile: BLE_periph.out
  ILINK.IlinkConfigDefines: gUseNVMLink_d=1; __heap_size__=0; __stack_size__=384; __ram_vector_table__=1
  ILINK.IlinkIcfFile: MKW40Z160xxx4_BLE.icf
  ILINK.IlinkAdditionalLibs: ..\BluetoothLE\ble_host_lib.a; ..\BluetoothLE\ble_controller_lib.a; ..\BluetoothLE\lib_crypto_IAR_M0.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; IAR; CPU_MKW40Z160VHT4
  ICCARM.PreInclude: examples/bluetooth/hid_device/frdmkw40z/FreeRTOS/app_preinclude.h
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  OBJCOPY.OOCOutputFile: generic.bin
  ILINK.IlinkOutputFile: hid_device_FreeRTOS.out
  ILINK.IlinkIcfFile: platform/devices/MKW40Z4/linker/iar/MKW40Z160xxx4_connectivity.icf
  ILINK.IlinkAdditionalLibs: bluetooth/host/lib/ble_host_peripheral_lib.a; $_KSDK_1_3_0_PATH_$\lib\ksdk_freertos_lib\iar\KW40Z4\release\libksdk_platform_freertos.a; framework/SecLib/lib_crypto_IAR_M0.a; bluetooth/controller/lib/ble_controller_lib.a
  group Firmware_Bluetooth/BLE_App
    ../BLE_App/: BLE_common_app.c BLE_common_app.h ble_controller_task.c ble_controller_task_config.h ble_host_task_config.h ble_host_tasks.c ble_host_tasks.h BLE_peripheral_app.c BLE_peripheral_app.h
  group Firmware_Bluetooth/BLE_App/Battery_Service
    ../BLE_App/Battery_Service/: battery_service.c
  group Firmware_Bluetooth/BLE_App/DeviceInfo_Service
    ../BLE_App/DeviceInfo_Service/: device_info_service.c
  group Firmware_Bluetooth/BLE_App/HeartRate_Service
    ../BLE_App/HeartRate_Service/: heart_rate_client.c heart_rate_service.c
  group Firmware_Bluetooth/BLE_App/HID_Service
    ../BLE_App/HID_Service/: hid_service.c
  group Firmware_Bluetooth/BLE_App/ImmediateAlert_Service
    ../BLE_App/ImmediateAlert_Service/: immediate_alert_service.c
  group Firmware_Bluetooth/BLE_App/K66BLEZ_services
    ../BLE_App/K66BLEZ_services/: K66BLE_CommandService.c K66BLE_CommandService.h K66BLE_CRC_utils.c K66BLE_CRC_utils.h K66BLE_Debug_print.h K66BLE_PerfTest.c K66BLE_PerfTest.h K66BLEZ.h K66BLEZ_channel.c K66BLEZ_channel.h
  group Firmware_Bluetooth/BLE_App/LinkLoss_Service
    ../BLE_App/LinkLoss_Service/: link_loss_service.c
  group Firmware_Bluetooth/BLE_App/TxPower_Service
    ../BLE_App/TxPower_Service/: tx_power_service.c
  group Firmware_Bluetooth/BLE_GATT_DB
    ../BLE_GATT_DB/: gatt_database.c
  group Firmware_Bluetooth/BluetoothLE
    ../BluetoothLE/: ble_globals.c hcit_serial_interface.c
  group Firmware_Bluetooth/Board
    ../Board/: board.c board.h BSP.c BSP.h BSP_DMA.c BSP_DMA.h BSP_pins.c BSP_pins.h BSP_PIT.c BSP_PIT.h BSP_SPI.c BSP_SPI.h hardware_init.c pin_mux.c pin_mux.h startup.c startup.h startup_MKW40Z4.s system_MKW40Z4.c system_MKW40Z4.h
  group Firmware_Bluetooth/Framework
    ../Framework/: BLEDefaults.h DCDC.c DCDC.h EmbeddedTypes.h fsl_osa_ext.h fsl_osa_ext_config.h fsl_osa_ext_freertos.c FunctionLib.c FunctionLib.h FwkInit.c GenericList.c GenericList.h GPIO_IrqAdapter.c Gpio_IrqAdapter.h ifr_mkw40z4_radio.c ifr_mkw40z4_radio.h KW4xXcvrDrv.c KW4xXcvrDrv.h MemManager.c MemManager.h Messaging.c Messaging.h ModuleInfo.h overwrites.h Panic.c Panic.h PWR.c PWR_BLE.c PWR_BLE.h PWR_Configuration.h PWR_Interface.h PWR_Platform.c PWR_Platform.h PWRLib.c PWRLib.h Reset.c RNG.c RNG_Interface.h SecLib.c SecLib.h SerialManager.c SerialManager.h TimersManager.c TimersManager.h TimersManagerInternal.h TMR_Adapter.c TMR_Adapter.h tsm_ll_timing.c tsm_ll_timing.h tsm_timing_ble.h tsm_timing_zigbee.h ZigbeeDefaults.h
  group Firmware_Bluetooth/Framework/Flash
    ../Framework/Flash/: CopyToRam.c DEFlashPartition.c DFlashGetProtection.c DFlashSetProtection.c EEEWrite.c EERAMGetProtection.c EERAMSetProtection.c Flash_Adapter.c FlashCheckSum.c FlashCommandSequence.c FlashEraseAllBlock.c FlashEraseResume.c FlashEraseSector.c FlashEraseSuspend.c FlashGetSecurityState.c FlashInit.c FlashProgram.c FlashProgramCheck.c FlashProgramOnce.c FlashProgramSection.c FlashReadOnce.c FlashReadResource.c FlashSecurityBypass.c FlashVerifyAllBlock.c FlashVerifyBlock.c FlashVerifySection.c PFlashGetProtection.c PFlashSetProtection.c PFlashSwap.c PFlashSwapCtl.c SetEEEEnable.c
  group Firmware_Bluetooth/FreeRTOS/port
    ../FreeRTOS/port/: port.c portasm.s
  group Firmware_Bluetooth/FreeRTOS/src
    ../FreeRTOS/src/: croutine.c event_groups.c heap_1.c heap_2.c heap_3.c heap_4.c heap_5.c list.c queue.c tasks.c timers.c
  group Firmware_Bluetooth/HAL
    ../HAL/: fsl_adc16_hal.c fsl_cmp_hal.c fsl_cmt_hal.c fsl_cop_hal.c fsl_dac_hal.c fsl_dma_hal.c fsl_dmamux_hal.c fsl_dspi_hal.c fsl_gpio_hal.c fsl_i2c_hal.c fsl_llwu_hal.c fsl_lptmr_hal.c fsl_ltc_hal.c fsl_mcg_hal.c fsl_mcg_hal_modes.c fsl_pit_hal.c fsl_port_hal.c fsl_rcm_hal.c fsl_rtc_hal.c fsl_sim_hal_MKW40Z4.c fsl_smc_hal.c fsl_tpm_hal.c fsl_trng_hal.c fsl_tsi_hal.c fsl_tsi_v4_hal_specific.c
  group Firmware_Bluetooth/OSA
    ../OSA/: fsl_os_abstraction_free_rtos.c
  group Firmware_Bluetooth/Peripherial
    ../Peripherial/: fsl_adc16_common.c fsl_adc16_driver.c fsl_adc16_driver.h fsl_bitaccess.h fsl_clock_manager.c fsl_clock_manager.h fsl_clock_manager_common.c fsl_clock_MKW40Z4.c fsl_clock_MKW40Z4.h fsl_cmp_common.c fsl_cmp_driver.c fsl_cmp_driver.h fsl_cmt_common.c fsl_cmt_driver.c fsl_cmt_driver.h fsl_cop_common.c fsl_cop_driver.c fsl_cop_driver.h fsl_dac_common.c fsl_dac_driver.c fsl_dac_driver.h fsl_device_registers.h fsl_dma_common.c fsl_dma_driver.c fsl_dma_driver.h fsl_dma_request.h fsl_dspi_common.c fsl_dspi_dma_master_driver.c fsl_dspi_dma_master_driver.h fsl_dspi_dma_slave_driver.c fsl_dspi_dma_slave_driver.h fsl_dspi_master_driver.c fsl_dspi_master_driver.h fsl_dspi_shared_function.c fsl_dspi_shared_function.h fsl_dspi_slave_driver.c fsl_dspi_slave_driver.h fsl_ftm_driver.h fsl_gpio_common.c fsl_gpio_driver.c fsl_gpio_driver.h fsl_hwtimer.c fsl_hwtimer.h fsl_hwtimer_pit.c fsl_hwtimer_pit.h fsl_hwtimer_systick.c fsl_hwtimer_systick.h fsl_i2c_common.c fsl_i2c_master_driver.c fsl_i2c_master_driver.h fsl_i2c_shared_function.c fsl_i2c_shared_function.h fsl_i2c_slave_driver.c fsl_i2c_slave_driver.h fsl_interrupt_manager.c fsl_interrupt_manager.h fsl_lptmr_common.c fsl_lptmr_driver.c fsl_lptmr_driver.h fsl_lpuart_common.c fsl_lpuart_dma_driver.c fsl_lpuart_dma_driver.h fsl_lpuart_driver.c fsl_lpuart_driver.h fsl_ltc_common.c fsl_ltc_driver.c fsl_ltc_driver.h fsl_ltc_driver_aes.c fsl_ltc_driver_aes.h fsl_ltc_driver_aes_ccm.c fsl_ltc_driver_hash.c fsl_ltc_driver_hash.h fsl_ltc_driver_prv.h fsl_pit_common.c fsl_pit_driver.c fsl_pit_driver.h fsl_power_manager.c fsl_power_manager.h fsl_power_manager_common.h fsl_rtc_common.c fsl_rtc_driver.c fsl_rtc_driver.h fsl_tpm_common.c fsl_tpm_driver.c fsl_tpm_driver.h fsl_trng_common.c fsl_trng_driver.c fsl_trng_driver.h fsl_tsi_common.c fsl_tsi_driver.c fsl_tsi_driver.h fsl_tsi_v4_driver_specific.c MKW40Z4.h MKW40Z4_extension.h MKW40Z4_features.h
  group Firmware_Bluetooth/RTT
    ../RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
